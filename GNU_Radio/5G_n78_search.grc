options:
  parameters:
    generate_options: qt_gui
    id: NR_n78_search
    output_language: python
    title: 5G NR Channel Search
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 3.55e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
